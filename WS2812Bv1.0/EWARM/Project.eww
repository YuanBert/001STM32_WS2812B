<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WS2812Bv1.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
